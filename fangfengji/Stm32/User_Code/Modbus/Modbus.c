#include "Modbus.h"

/****************************私有宏定义*******************************/

/****************************私有函数声明*****************************/
u16 CheckCRC16(u8 *ucDataBuff,u16 ucDataLength);//CheckCRC16
/****************************私有全局变量定义*************************/
static u8 auchCRCHi[256] = {   
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,    
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,    
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,    
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,    
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,    
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,    
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,    
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,    
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,    
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,    
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,    
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,    
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,    
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,    
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,    
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,    
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,    
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,    
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,    
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,    
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,    
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40,    
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1,    
    0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,    
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,    
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40   
};    
  
static u8 auchCRCLo[256] = {   
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06,    
    0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD,    
    0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,    
    0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A,    
    0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4,    
    0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,    
    0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3,    
    0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4,    
    0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,    
    0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29,    
    0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED,    
    0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,    
    0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60,    
    0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67,    
    0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,    
    0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68,    
    0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E,    
    0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,    
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71,    
    0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92,    
    0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,    
    0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B,    
    0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B,    
    0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,    
    0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42,    
    0x43, 0x83, 0x41, 0x81, 0x80, 0x40   
};
static u8 SlaveAddr=0xfe;        /*通讯地址，开机默认通讯地址=1 */
/****************************公有全局变量定义*************************/
//虚拟寄存器
u8 Register[255] = {
0x00,0xfe,//设备ID
0x00,0x00,//显示使能
0x00,0x00,//风口号
0x00,0x00,//风口长度
0x00,0x1E,//当前温度
0x00,0x00,//温度趋势
0x00,0x25,//温度上限
0x00,0x21,//温度下限
0x00,0x03,//电机状态
0x00,0x02,//控制模式
};
u8 ModbusTXBuf[255];//modbus发送缓存 
u8 ChangeData = 0;//数据改变标记
/****************************私有函数*********************************/
/****************************************************************************
* 名    称：CheckCRC16
* 功    能：crc 校验
* 入口参数：u8*ucDataBuff：接收的数组,u16 ucDataLength：数组长度
* 出口参数：无
* 说    明：
* 调用方法：无 
****************************************************************************/
u16 CheckCRC16(u8 *ucDataBuff,u16 ucDataLength)
{
  u8 uchCRCHi = 0xFF ; 
  u8 uchCRCLo = 0xFF ;  
  u8 uIndex = 0; 
  
  while (ucDataLength--) 
  {    
    uIndex = uchCRCHi ^ *ucDataBuff++ ;   
    uchCRCHi = uchCRCLo ^ auchCRCHi[uIndex] ;    
    uchCRCLo = auchCRCLo[uIndex] ;    
  }   
  
  return (u16)((u16)uchCRCHi << 8 | uchCRCLo); 
}

//指令校验 
u8 FrameCheck(u8* FrameData)
{
  u16 TempCrc1 = 0,TempCrc2 = 0;
  u16 length = 0;
  //检查ID是否正确
  if( FrameData[0] != SlaveAddr) 
  {
    return 0; 
  } 
  //检查CRC
  if( (FrameData[1] == 0x03) || (FrameData[1] == 0x06))//数据读取和单数据写入
  {
    TempCrc1 = CheckCRC16(FrameData,6);
    TempCrc2 = FrameData[6]*256 + FrameData[7];
    if(TempCrc1 != TempCrc2)
    {
      return 0;
    }
  } 
  else if( FrameData[1] == 0x10)//数据连续写入 
  {
    length = (FrameData[4]*256 + FrameData[5])*2 + 7;	
    TempCrc1 = CheckCRC16(FrameData,length);
    TempCrc2 = FrameData[length]*256 + FrameData[length+1];
    if(TempCrc1 != TempCrc2)
    {
      return 0;
    }	
  }
  return 1; 
}

//读取指令 
u8* ModBus_Command03(u8* FrameData)
{
  u16 Addr = 0;
  u16 CRC16=0xffff; 
  u8 OffAddr = 3;
  u8 StartAddr = FrameData[3]; 
  u8 RegNum =  FrameData[5];
  u16 EndAddr=StartAddr+RegNum*2;//计算最后一个被读取的寄存器地址
   
  ModbusTXBuf[0] = SlaveAddr;//返回地址     
  ModbusTXBuf[1] = 0x03;//返回功能码 03  
  ModbusTXBuf[2] = RegNum%256*2;//返回数据区字节数(2*寄存器数)       
  
  for(Addr = StartAddr;Addr < EndAddr;Addr++)     //按照命令要求依次返回数据
  {
    ModbusTXBuf[OffAddr++] = Register[Addr];//RegNum个寄存器，依次发送
  }
  
  CRC16 = CheckCRC16(ModbusTXBuf,OffAddr); 
   
  ModbusTXBuf[OffAddr++] = CRC16/256; //CRC,低位在先
  ModbusTXBuf[OffAddr++] = CRC16%256;
  
  return ModbusTXBuf;
}

//单数据写入 
u8* ModBus_Command06(u8* FrameData)
{           
  u8 WR_Addr = FrameData[3];
  u8 i = 0;
   
  //将数据存入相应的寄存器中
  Register[WR_Addr]= FrameData[4];    
  Register[WR_Addr+1]= FrameData[5];      
  
  for(i = 0;i < 8;i++)  
  {
    ModbusTXBuf[i] = FrameData[i];
  } 
  ChangeData = 1;
  return ModbusTXBuf;	
}

//连续写入 
u8* ModBus_Command16(u8* FrameData)
{
  u8 StartAddr = FrameData[3]; 
  u8 RegNum =  FrameData[5];
  u8 OffAddr = 7;
  u16 EndAddr=StartAddr+RegNum*2;   //计算最后一个被写入的寄存器地址
  u16 Addr,i=0;
  u16 CRC16=0xffff; 
  
  for(Addr=StartAddr;Addr<EndAddr;Addr++)  //从起始地址开始，依次写入
  {
    Register[Addr] =  FrameData[OffAddr++];
  } 
  for(i = 0;i < 6;i++)
  {
    ModbusTXBuf[i] = FrameData[i]; 
  }
  CRC16 = CheckCRC16(ModbusTXBuf,6); 
   
  ModbusTXBuf[6] = CRC16/256; //CRC,低位在先
  ModbusTXBuf[7] = CRC16%256;
  
  ChangeData = 1;
  return ModbusTXBuf;
}

/****************************公有函数*********************************/

/****************************************************************************
* 名    称：DisplayNumGet
* 功    能：获取主页面显示的数据
* 入口参数：u8 DisplayType：获取的数据
* 出口参数：u8：显示的数字
* 说    明：
* 调用方法：无 
****************************************************************************/
u8 DisplayF0NumGet(u8 DisplayType)
{
  u8 Num = 0;
  if(Register[DisplayE+1] != 1)
  {
    return '0';
  }
  
  switch(DisplayType)
  {
    case D_RopeNum_H:   //风口号H
            Num =  '0' + (Register[RopeNum_H]*255 + Register[RopeNum_L])/10;
            break;
    case D_RopeNum_L:   //风口号L
            Num =  '0' + (Register[RopeNum_H]*255 + Register[RopeNum_L])%10;
            break;
    case D_RopeLen_H:   //风口长度H
            Num =  '0' + (Register[RopeLen_H]*255 + Register[RopeLen_L])/100;
            break;
    case D_RopeLen_M:   //风口长度M
            Num =  '0' + ((Register[RopeLen_H]*255 + Register[RopeLen_L])/10)%10;
            break;
    case D_RopeLen_L:   //风口长度L
            Num =  '0' + (Register[RopeLen_H]*255 + Register[RopeLen_L])%10;
            break;
    case D_CurTemp_H:   //当前温度H
            Num =  '0' + ((Register[CurTemp_H]<<8)|Register[CurTemp_L])/10;
            break;
    case D_CurTemp_L:   //当前温度L
            Num =  '0' + ((Register[CurTemp_H]<<8)|Register[CurTemp_L])%10;
            break;  
    case D_TemTrend:    //温度趋势
            break;
    case D_TemH_H:      //温度上限H
            Num =  '0' + ((Register[TemH_H]<<8)|Register[TemH_L])/10;
            break;  
    case D_TemH_L:      //温度上限L
            Num =  '0' + ((Register[TemH_H]<<8)|Register[TemH_L])%10;
            break;        
    case D_TemL_H:      //温度下限H
            Num =  '0' + ((Register[TemL_H]<<8|Register[TemL_L]))/10;
            break;  
    case D_TemL_L:      //温度下限L
            Num =  '0' + ((Register[TemL_H]<<8|Register[TemL_L]))%10;
            break;                
    case D_MotoSta:     //电机状态H
            Num =  Register[MotoSta + 1];
            break;  
    case D_CtrlMode:    //控制模式H
            Num =  Register[CtrlMode + 1];
            break;  
    default:
            break;
  }
  
  return Num;
}

//数据帧处理
u8* FrameDeal(u8* FrameData)
{
  u8 *pTX  = 0;
  //待发送的数据地址 
  //帧检查   
  if( FrameCheck(FrameData) != 1)
  {
    return 0;
  } 
 
  //异常帧处理
  //寄存器地址错误
  //读取长度错误
  //非法指令 
  //帧处理 
  
  switch(FrameData[1])
  {
    case 0x03://读命令 
                    pTX = ModBus_Command03(FrameData); 
                    break;
    case 0x06://单数据写入 
                    pTX = ModBus_Command06(FrameData); 
                    break;
    case 0x10://连续数据写入 
                    pTX = ModBus_Command16(FrameData);
                    break;
    default: 
                    pTX = 0;
                    break;	
  }	
  return pTX;	
} 

//获取回复数据帧的长度
u8 GetFrameLen(u8* FrameData)
{
  if(FrameData[1] == 0x03)
  {
    return (FrameData[2] + 5);
  }
  else if(FrameData[1] == 0x06)
  {
    return 8;
  }
  else if(FrameData[1] == 0x10)
  {
    return 8;
  }  
  
  return 0;
}




