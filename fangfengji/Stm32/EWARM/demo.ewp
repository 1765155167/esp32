# IAR project demo.ewp, settings and files
configuration demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030C8 ST STM32F030C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x8
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ..\User_Code\Hard_Module\Serial_Port\Usart_Magagement; ..\User_Code; ..\User_Code\Hard_Module\Time\Time3; ..\User_Code\Hard_Module\Time\Time_Magagement; ..\User_Code\Hard_Module\Serial_Port\Usart2; ..\User_Code\Hard_Module\Serial_Port\Usart1; ..\User_Code\Hard_Module\GPIO_C; ..\User_Code\Display; ..\User_Code\command; ..\User_Code\Modbus; ..\User_Code\Hard_Module\Time\Time6
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: stm32f030x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../Src/: main.c gpio.c dma.c iwdg.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c main.c gpio.c dma.c iwdg.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_iwdg.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group User_Code
    ../User_Code/: global.c User_Deal_Code.c
  group User_Code/Command
    ../User_Code/command/: command.c
  group User_Code/Display
    ../User_Code/Display/: DisplayList.c PointSelect.c
  group User_Code/Hard_Module/GPIO_C
    ../User_Code/Hard_Module/GPIO_C/: gpio_c.c
  group User_Code/Hard_Module/Serial_Port
    ../User_Code/Hard_Module/Serial_Port/Usart1/: Usart1.c
    ../User_Code/Hard_Module/Serial_Port/Usart2/: Usart2.c
    ../User_Code/Hard_Module/Serial_Port/Usart_Magagement/: Usart_Magagement.c
  group User_Code/Hard_Module/Time
    ../User_Code/Hard_Module/Time/Time3/: Time3.c
    ../User_Code/Hard_Module/Time/Time6/: Time6.c
    ../User_Code/Hard_Module/Time/Time_Magagement/: Time_Magagement.c
  group User_Code/Modbus
    ../User_Code/Modbus/: Modbus.c
