# Keil uVision project demo.uvprojx, settings and files
target demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ..\User_Code; ..\User_Code\command; ..\User_Code\Display; ..\User_Code\Hard_Module\GPIO_C; ..\User_Code\Hard_Module\Serial_Port\Usart_Magagement; ..\User_Code\Hard_Module\Serial_Port\Usart1; ..\User_Code\Hard_Module\Serial_Port\Usart2; ..\User_Code\Hard_Module\Time\Time_Magagement; ..\User_Code\Hard_Module\Time\Time3; ..\User_Code\Hard_Module\Time\Time6; ..\User_Code\Hard_Module\Time\Time14; ..\User_Code\Modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../User_Code/: global.c User_Deal_Code.c
    ../Src/: main.c gpio.c dma.c iwdg.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_iwdg.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group command
    ../User_Code/command/: command.c
  group Display
    ../User_Code/Display/: DisplayList.c PointSelect.c
  group Hard_Module
    ../User_Code/Hard_Module/GPIO_C/: gpio_c.c
    ../User_Code/Hard_Module/Serial_Port/Usart_Magagement/: Usart_Magagement.c
    ../User_Code/Hard_Module/Serial_Port/Usart1/: Usart1.c
    ../User_Code/Hard_Module/Serial_Port/Usart2/: Usart2.c
    ../User_Code/Hard_Module/Time/Time_Magagement/: Time_Magagement.c
    ../User_Code/Hard_Module/Time/Time3/: Time3.c
    ../User_Code/Hard_Module/Time/Time6/: Time6.c
    ../User_Code/Hard_Module/Time/Time14/: Time14.c
  group Modbus
    ../User_Code/Modbus/: Modbus.c
software components: CMSIS:CORE 4.3.0
